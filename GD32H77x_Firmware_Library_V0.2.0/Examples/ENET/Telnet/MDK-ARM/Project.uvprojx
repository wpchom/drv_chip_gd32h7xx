# Keil uVision project Project.uvprojx, settings and files
target gd32h77x_ENET (6160000::V6.16::ARMCLANG)
  device: GD32H77EIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.0.8
  cpu: IRAM(0x24000000,0x00080000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x0200000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H77X
  c include: ..\inc;..\lwip-2.2.1\src\include;..\lwip-2.2.1\src\include\lwip;..\lwip-2.2.1\src\include\netif;..\lwip-2.2.1\port\GD32H77x;..\lwip-2.2.1\port\GD32H77x\Basic;..\..\..\..\Firmware\CMSIS;..\..\..\..\Firmware\GD32H77x_standard_peripheral\Include;..\..\..\..\Firmware\CMSIS\GD\GD32H77x\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
  group Application
    ../src/: main.c netconf.c hello_gigadevice.c gd32h77x_enet_eval.c gd32h77x_it.c gd32h77x_enet_ext.c
  group GD32H77x_Peripherals
    ../../../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_adc.c gd32h77x_can.c gd32h77x_cau.c gd32h77x_cau_aes.c gd32h77x_cmp.c gd32h77x_cpdm.c gd32h77x_crc.c gd32h77x_ctc.c gd32h77x_dac.c gd32h77x_dbg.c gd32h77x_dci.c gd32h77x_dma.c gd32h77x_dsi.c gd32h77x_edim_afmt.c gd32h77x_edim_biss.c gd32h77x_edim_endat.c gd32h77x_edim_hdsl.c gd32h77x_edim_tfmt.c gd32h77x_edout.c gd32h77x_enet.c gd32h77x_esc.c gd32h77x_exmc.c gd32h77x_exti.c gd32h77x_fac.c gd32h77x_fft.c gd32h77x_fwdgt.c gd32h77x_gpio.c gd32h77x_gpsi.c gd32h77x_hau.c gd32h77x_hau_sha_md5.c gd32h77x_hpdf.c gd32h77x_hwsem.c gd32h77x_i2c.c gd32h77x_ipa.c gd32h77x_lpdts.c gd32h77x_mdio.c gd32h77x_mdma.c gd32h77x_misc.c gd32h77x_nvmc.c gd32h77x_ospi.c gd32h77x_ospim.c gd32h77x_pkcau.c gd32h77x_pmu.c gd32h77x_rameccmu.c gd32h77x_rcu.c gd32h77x_rdcm.c gd32h77x_rspdif.c gd32h77x_rtc.c gd32h77x_rtdec.c gd32h77x_sai.c gd32h77x_sdio.c gd32h77x_spi.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_tli.c gd32h77x_tmu.c gd32h77x_trigsel.c gd32h77x_trng.c gd32h77x_usart.c gd32h77x_vref.c gd32h77x_wwdgt.c
  group Lwip
    ../lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.2.1/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.2.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.2.1/src/netif/: ethernet.c
  group Lwip_port
    ../lwip-2.2.1/port/GD32H77x/Basic/: ethernetif.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32H77x/Source/: system_gd32h77x.c
    ../../../../Firmware/CMSIS/GD/GD32H77x/Source/ARM/: startup_gd32h77x.s
  group GD32H77x_EVAL
    ../../../../Utilities/: gd32h77ei_eval.c
  group Doc
    ../src/: readme.txt
software components: CMSIS:CORE 5.5.0
