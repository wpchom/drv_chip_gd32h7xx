# Keil uVision project msc_udisk.uvprojx, settings and files
target GD32H77X(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H77EIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.0.7
  cpu: IRAM(0x24000000,0x00080000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x0200000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: msc_udisk +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS USE_USBHS0  GD32H77EXW,VECT_TAB_FLASH
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32H77x\Include;..\..\..\..\..\Firmware\GD32H77x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32H77x_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32H77x_usbhs_library\device\core\Include;..\..\..\..\..\Firmware\GD32H77x_usbhs_library\device\class\msc\Include;..\..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\common;..\..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\class\msc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
  group Application
    ../src/: app.c gd32h77x_it.c gd32h77x_usb_hw.c flash_msd.c usbd_storage_msd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H77x/Source/: system_gd32h77x.c gd32h77x_err_report.c
  group GD32H77x_Peripherals
    ../../../../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_ctc.c gd32h77x_exti.c gd32h77x_gpio.c gd32h77x_misc.c gd32h77x_nvmc.c gd32h77x_pmu.c gd32h77x_rcu.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_usart.c
  group GD32H77x_EVAL
    ../../../../../Utilities/: gd32h77ei_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H77x/Source/ARM/: startup_gd32h77x.s
  group USB_Driver
    ../../../../../Firmware/GD32H77x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32H77x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32H77x_usbhs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Doc
    ../: readme.txt
target GD32H77X(USB_HS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H77EIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.0.7
  cpu: as above
  output: msc_udisk +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H77EXW,USE_USB_HS USE_USBHS0,VECT_TAB_FLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
target GD32H77X(USB_ULPI) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H77EIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.0.7
  cpu: as above
  output: msc_udisk +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H77EXW,USE_USB_HS USE_USBHS0,USE_ULPI_PHY,VECT_TAB_FLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
software components: CMSIS:CORE 5.3.0
