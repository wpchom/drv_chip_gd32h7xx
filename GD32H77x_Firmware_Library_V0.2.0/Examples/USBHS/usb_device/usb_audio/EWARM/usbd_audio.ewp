# IAR project usbd_audio.ewp, settings and files
configuration GD32H77x_USBFS_IIS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H77xxW GD GD32H77xxW
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H77EXW; VECT_TAB_FLASH; USE_USB_FS; USE_USBHS0; USE_USB_AD_SPEAKER; USE_IIS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H77x\Include; ..\..\..\..\..\Firmware\GD32H77x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\device\class\audio\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\common; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_audio.srec
  ILINK.IlinkOutputFile: usbd_audio.out
  group App
    ../src/: app.c audio_iis_codec.c gd32h77x_it.c gd32h77x_usb_hw.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H77x/Source/: system_gd32h77x.c
  group Doc
    ../: readme.txt
  group GD32H77x_EVAL
    ../../../../../Utilities/: gd32h77ei_eval.c
  group GD32H77x_Peripherals
    ../../../../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_dma.c gd32h77x_exti.c gd32h77x_gpio.c gd32h77x_misc.c gd32h77x_nvmc.c gd32h77x_pmu.c gd32h77x_rcu.c gd32h77x_sai.c gd32h77x_spi.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H77x/Source/IAR/: startup_gd32h77x.s
  group USB_Class
    ../../../../../Firmware/GD32H77x_usbhs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32H77x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32H77x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
