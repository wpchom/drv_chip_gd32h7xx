# IAR project hid_keyboard.ewp, settings and files
configuration GD32H77x_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H77xxW GD GD32H77xxW
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H77EXW; VECT_TAB_FLASH; USE_USB_FS; USE_USBHS0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H77x\Include; ..\..\..\..\..\Firmware\GD32H77x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\class\hid; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: hid_keyboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H77x_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H77EXW; VECT_TAB_FLASH; USE_USB_HS; USE_USBHS0
configuration GD32H77x_ULPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H77EXW; VECT_TAB_FLASH; USE_USB_HS; USE_USBHS0; USE_ULPI_PHY
  ICCARM.CCOptStrategy: 1
  group App
    ../src/: app.c gd32h77x_it.c gd32h77x_usb_hw.c gd32h77x_usb_test.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32h77x.c
  group Doc
    ../: readme.txt
  group GD32H77x_EVAL
    ../../../../../Utilities/: gd32h77ei_eval.c
  group GD32H77x_Peripherals
    ../../../../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_exti.c gd32h77x_gpio.c gd32h77x_misc.c gd32h77x_nvmc.c gd32h77x_pmu.c gd32h77x_rcu.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H77x/Source/IAR/: startup_gd32h77x.s
  group USB_Class
    ../../../../../Firmware/GD32H77x_usbhs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../Firmware/GD32H77x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32H77x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
