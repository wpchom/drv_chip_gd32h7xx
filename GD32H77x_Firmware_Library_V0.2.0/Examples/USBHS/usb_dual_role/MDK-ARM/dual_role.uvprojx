# Keil uVision project dual_role.uvprojx, settings and files
target usb_dual_role (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H77EIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.0.7
  cpu: IRAM(0x24000000,0x00080000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x0200000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: dual_role +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,USE_USB_HS USE_USBHS0, USE_USBHS1, GD32H77EXW,VECT_TAB_FLASH
  c include: ..\inc;..\fat_fs\inc;..\..\..\..\Firmware\CMSIS;..\..\..\..\Firmware\CMSIS\GD\GD32H77x\Include;..\..\..\..\Firmware\GD32H77x_standard_peripheral\Include;..\..\..\..\Firmware\GD32H77x_usbhs_library\driver\Include;..\..\..\..\Firmware\GD32H77x_usbhs_library\device\core\Include;..\..\..\..\Firmware\GD32H77x_usbhs_library\host\core\Include;..\..\..\..\Firmware\GD32H77x_usbhs_library\device\class\hid\Include;..\..\..\..\Firmware\GD32H77x_usbhs_library\host\class\msc\Include;..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\common;..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\class\hid;..\..\..\..\Firmware\GD32H77x_usbhs_library\ustd\class\msc;..\..\..\..\Utilities;..\..\..\..\Utilities\LCD_common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
  group Application
    ../src/: app.c custom_hid_itf.c gd32h77x_it.c gd32h77x_usb_hw.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32h77x.c
    ../../../../Firmware/CMSIS/GD/GD32H77x/Source/: gd32h77x_err_report.c
  group GD32H77x_Peripherals
    ../../../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_ctc.c gd32h77x_exti.c gd32h77x_gpio.c gd32h77x_misc.c gd32h77x_pmu.c gd32h77x_rcu.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_usart.c gd32h77x_exmc.c gd32h77x_tli.c gd32h77x_nvmc.c
  group GD32H77x_EVAL
    ../../../../Utilities/: gd32h77ei_eval.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32H77x/Source/ARM/: startup_gd32h77x.s
  group USB_Driver
    ../../../../Firmware/GD32H77x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c drv_usb_host.c drv_usbh_int.c
  group USB_Device
    ../../../../Firmware/GD32H77x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Host
    ../../../../Firmware/GD32H77x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USBD_Class
    ../../../../Firmware/GD32H77x_usbhs_library/device/class/hid/Source/: custom_hid_core.c
  group USBH_Class
    ../../../../Firmware/GD32H77x_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FatFs
    ../fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
