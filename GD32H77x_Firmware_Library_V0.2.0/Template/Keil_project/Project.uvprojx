# Keil uVision project Project.uvprojx, settings and files
target GD32H77E (6160000::V6.16::ARMCLANG)
  device: GD32H77EIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.1.1
  cpu: IRAM(0x24000000,0x00080000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x0200000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H77EXW,FW_DEBUG_ERR_REPORT,VECT_TAB_FLASH
  c include: ..\..\Template;..\..\Firmware\CMSIS\GD\gd32h77x\Include;..\..\Firmware\gd32h77x_standard_peripheral\Include;..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../: main.c gd32h77x_it.c systick.c
  group Peripherals
    ../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_adc.c gd32h77x_can.c gd32h77x_cau.c gd32h77x_cau_aes.c gd32h77x_cmp.c gd32h77x_cpdm.c gd32h77x_crc.c gd32h77x_ctc.c gd32h77x_dac.c gd32h77x_dbg.c gd32h77x_dci.c gd32h77x_dma.c gd32h77x_dsi.c gd32h77x_edim_afmt.c gd32h77x_edim_biss.c gd32h77x_edim_endat.c gd32h77x_edim_hdsl.c gd32h77x_edim_tfmt.c gd32h77x_edout.c gd32h77x_enet.c gd32h77x_esc.c gd32h77x_exmc.c gd32h77x_exti.c gd32h77x_fac.c gd32h77x_fft.c gd32h77x_fwdgt.c gd32h77x_gpio.c gd32h77x_gpsi.c gd32h77x_hau.c gd32h77x_hau_sha_md5.c gd32h77x_hpdf.c gd32h77x_hwsem.c gd32h77x_i2c.c gd32h77x_ipa.c gd32h77x_lpdts.c gd32h77x_mdio.c gd32h77x_mdma.c gd32h77x_misc.c gd32h77x_nvmc.c gd32h77x_ospi.c gd32h77x_ospim.c gd32h77x_pkcau.c gd32h77x_pmu.c gd32h77x_rameccmu.c gd32h77x_rcu.c gd32h77x_rdcm.c gd32h77x_rspdif.c gd32h77x_rtc.c gd32h77x_rtdec.c gd32h77x_sai.c gd32h77x_sdio.c gd32h77x_spi.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_tli.c gd32h77x_tmu.c gd32h77x_trigsel.c gd32h77x_trng.c gd32h77x_usart.c gd32h77x_vref.c gd32h77x_wwdgt.c
  group CMSIS
    ../../Firmware/CMSIS/GD/gd32h77x/Source/: system_gd32h77x.c
    ../../Firmware/CMSIS/GD/GD32H77x/Source/: gd32h77x_err_report.c
  group Startup
    ../../Firmware/CMSIS/GD/gd32h77x/Source/arm/: startup_gd32h77x.s
  group Utilities
    ../../Utilities/: gd32h77ei_eval.c
  group Doc
    ../: readme.txt
target GD32H77D (6160000::V6.16::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.1.1
  cpu: IRAM(0x24000000,0x00080000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x0200000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H77DXW,FW_DEBUG_ERR_REPORT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
target GD32H779 (6160000::V6.16::ARMCLANG)
  device: GD32H779VW GigaDevice
  pack: GigaDevice.GD32H77x_DFP.0.1.1
  cpu: as above
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H779XW,FW_DEBUG_ERR_REPORT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x20000
software components: CMSIS:CORE 5.5.0
