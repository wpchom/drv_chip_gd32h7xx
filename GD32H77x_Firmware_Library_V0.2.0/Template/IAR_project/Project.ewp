# IAR project Project.ewp, settings and files
configuration GD32H77E (ARM, debug)
  General.OGChipSelectEditMenu: GD32H77xxW GD GD32H77xxW
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H77EXW; FW_DEBUG_ERR_REPORT; VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\..\Utilities; ..; ..\..\Firmware\GD32H77x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32H77x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H77D (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H77DXW; FW_DEBUG_ERR_REPORT
configuration GD32H779 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32H779XW; FW_DEBUG_ERR_REPORT
  group Application
    ../: gd32h77x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32H77x/Source/: gd32h77x_err_report.c system_gd32h77x.c
  group Doc
    ../: readme.txt
  group GD32H77x_EVAL
    ../../Utilities/: gd32h77ei_eval.c
  group GD32H77x_Peripherals
    ../../Firmware/GD32H77x_standard_peripheral/Source/: gd32h77x_adc.c gd32h77x_can.c gd32h77x_cau.c gd32h77x_cau_aes.c gd32h77x_cmp.c gd32h77x_cpdm.c gd32h77x_crc.c gd32h77x_ctc.c gd32h77x_dac.c gd32h77x_dbg.c gd32h77x_dci.c gd32h77x_dma.c gd32h77x_dsi.c gd32h77x_edim_afmt.c gd32h77x_edim_biss.c gd32h77x_edim_endat.c gd32h77x_edim_hdsl.c gd32h77x_edim_tfmt.c gd32h77x_edout.c gd32h77x_enet.c gd32h77x_esc.c gd32h77x_exmc.c gd32h77x_exti.c gd32h77x_fac.c gd32h77x_fft.c gd32h77x_fwdgt.c gd32h77x_gpio.c gd32h77x_gpsi.c gd32h77x_hau.c gd32h77x_hau_sha_md5.c gd32h77x_hpdf.c gd32h77x_hwsem.c gd32h77x_i2c.c gd32h77x_ipa.c gd32h77x_lpdts.c gd32h77x_mdio.c gd32h77x_mdma.c gd32h77x_misc.c gd32h77x_nvmc.c gd32h77x_ospi.c gd32h77x_ospim.c gd32h77x_pkcau.c gd32h77x_pmu.c gd32h77x_rameccmu.c gd32h77x_rcu.c gd32h77x_rdcm.c gd32h77x_rspdif.c gd32h77x_rtc.c gd32h77x_rtdec.c gd32h77x_sai.c gd32h77x_sdio.c gd32h77x_spi.c gd32h77x_syscfg.c gd32h77x_timer.c gd32h77x_tli.c gd32h77x_tmu.c gd32h77x_trigsel.c gd32h77x_trng.c gd32h77x_usart.c gd32h77x_vref.c gd32h77x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32H77x/Source/IAR/: startup_gd32h77x.s
